# Keil uVision project SafetyRecognition.uvprojx, settings and files
target SafetyRecognition (6230000::V6.23::ARMCLANG)
  device: M55M1H2LJAE Nuvoton
  pack: Nuvoton.NuMicroM55_DFP.1.0.1
  cpu: IRAM(0x20100000,0x150000) IRAM2(0x30100000,0x150000) IROM(0x00100000,0x200000) IROM2(0x10100000,0x200000) CPUTYPE("Cortex-M55") FPU3(DFPU) DSP TZ MVE(FP) CLOCK(12000000) ESEL ELITTLE
  output: SafetyRecognition
  AfterMake: fromelf --bin ".\Objects\@L.axf" --output  ".\Objects\@L.bin"
  c flags: Optim=3 OneElfS=1 v6Lang=5 v6LangP=6 wLevel=3
  c define: NVT_VECTOR_ON_FLASH, TF_LITE_STATIC_MEMORY, ARM_MATH_DSP, ARM_NPU, ACTIVATION_BUF_SZ=0x00010000
  c include: ..\..\..\..\Library\CMSIS\Core\Include;..\..\..\..\Library\Device\Nuvoton\M55M1\Include;..\..\..\..\Library\CMSIS\DSP\Include;..\..\..\..\Library\StdDriver\inc;..\..\..\..\Library\StdDriver\inc\npu;..\..\..\..\ThirdParty\openmv\omv\imlib;..\..\..\..\ThirdParty\openmv\omv\alloc;..\..\..\..\ThirdParty\openmv\omv\common;..\..\..\..\ThirdParty\openmv\omv\Lib;..\..\..\..\ThirdParty\tflite_micro;..\..\..\..\ThirdParty\tflite_micro\_deps\tensorflow-flatbuffers-src\include;..\..\..\..\ThirdParty\ml-embedded-evaluation-kit\source\application\api\common\include;..\..\..\..\ThirdParty\ml-embedded-evaluation-kit\source\log\include;..\..\..\..\ThirdParty\ml-embedded-evaluation-kit\source\math\include;..\..\..\..\ThirdParty\ml-embedded-evaluation-kit\source\application\main\include;..\..\..\..\ThirdParty\ml-embedded-evaluation-kit\source\profiler\include;..\Device\include;..\Model\include;..\NPU\include;..\Pattern\include;..\ProfilerCounter\include;..\;..\..\..\..\ThirdParty\tflite_micro\_deps\tensorflow-gemlowp-src;..\..\..\..\ThirdParty\FatFs\source;..\..\..\..\ThirdParty\as608\src;..\..\..\..\ThirdParty\as608\example
  memory RVCT4: ROM 0x100000 size 0x200000
  memory RVCT5: ROM 0x10100000 size 0x200000
  memory RVCT9: RAM 0x20100000 size 0x150000
  memory RVCT10: RAM 0x30100000 size 0x150000
  scatter file: .\M55M1.scatter
  group CMSIS
    ../../../../Library/Device/Nuvoton/M55M1/Source/: startup_M55M1.c system_M55M1.c
  group Driver
    ../../../../Library/StdDriver/src/: uart.c retarget.c ccap.c clk.c sys.c gpio.c spim_hyper.c ebi.c sdh.c spi.c hsusbd.c pdma.c
    ../../../../Library/StdDriver/src/npu/: ethosu_device_u55_u65.c ethosu_driver.c ethosu_pmu.c
  group Application
    ../: BoardInit.cpp main.cpp Recognizer.cpp FaceRecognProcessing.cpp mpu_config_M55M1.h ModelFileReader.c FaceDetectorPostProcessing.cpp LabelFileReader.c ImgClassProcessing.cpp
  group Lib
    ../../../../ThirdParty/tflite_micro/Lib/: tflu.lib
    ../../../../Library/CMSIS/Lib/KEIL/: cmsis_dsp.lib cmsis_nn.lib
    ../../../../ThirdParty/openmv/omv/Lib/: omv.lib
  group Model
    ../Model/: Labels.cpp face_detection_int8_vela_H256.tflite.cpp FaceDetectionModel.cpp FaceMobileNetModel.cpp FaceAntiSpoofModel.cpp Labels_cls.cpp
  group Pattern
    ../Pattern/: InputFiles.cpp test1_qvga.cpp test2_qvga.cpp test3_qvga.cpp test4_qvga.cpp test5_qvga.cpp test6_qvga.cpp test7_qvga.cpp test8_qvga.cpp test9_qvga.cpp test10_qvga.cpp
  group ArmMLApi
    ../../../../ThirdParty/ml-embedded-evaluation-kit/source/application/api/common/source/: Model.cc TensorFlowLiteMicro.cc Classifier.cc ImageUtils.cc
    ../../../../ThirdParty/ml-embedded-evaluation-kit/source/math/: PlatformMath.cc
    ../../../../ThirdParty/ml-embedded-evaluation-kit/source/profiler/: Profiler.cc
  group NPU
    ../NPU/: ethosu_cpu_cache.c ethosu_npu_init.c ethosu_profiler.c
  group ProfilerCounter
    ../ProfilerCounter/: pmu_counter.c
  group Device
    ../Device/ImageSensor/: ImageSensor.c
    ../Device/ImageSensor/Sensor/: Sensor_HM1055.c SWI2C.c
    ../Device/Display/: Font8_16.c Display.c drv_pdma.c
    ../Device/Display/LCD/: LCD_FSA506.c LCD_ILI9341.c LCD_LT7381.c
    ../Device/HyperRAM/: hyperram_code.c
    ../Device/SDCard/: sdglue.c
    ../Device/UVC/: descriptors.c UVC.c
    ../../../../Library/Storage/: diskio_SDH.c
  group FatFS
    ../../../../ThirdParty/FatFs/source/: ff.c ffunicode.c
  group FingerprintScanner
    ../../../../ThirdParty/as608/src/: driver_as608.c
    ../../../../ThirdParty/as608/example/: driver_as608_basic.c
    ../Device/Fingerprint/: driver_as608_interface_pdma.c
