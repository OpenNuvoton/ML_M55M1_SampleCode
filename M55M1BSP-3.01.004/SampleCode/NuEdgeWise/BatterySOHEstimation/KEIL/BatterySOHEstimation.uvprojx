# Keil uVision project BatterySOHEstimation.uvprojx, settings and files
target BatterySOHEstimation (6230000::V6.23::ARMCLANG)
  device: M55M1H2LJAE Nuvoton
  pack: Nuvoton.NuMicroM55_DFP.3.1.3
  cpu: IRAM(0x20100000,0x150000) IRAM2(0x30100000,0x150000) IROM(0x00100000,0x200000) IROM2(0x10100000,0x200000) CPUTYPE("Cortex-M55") FPU3(DFPU) DSP TZ MVE(FP) CLOCK(12000000) ESEL ELITTLE
  output: BatterySOHEstimation
  AfterMake: fromelf --bin ".\build\@L.axf" --output ".\build\@L.bin"
  AfterMake: fromelf --text -c ".\build\@L.axf" --output ".\build\@L.txt"
  c flags: Optim=3 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=6 wLevel=3
  c define: NVT_VECTOR_ON_FLASH, TF_LITE_STATIC_MEMORY, ARM_MATH_DSP, ARM_NPU, ACTIVATION_BUF_SZ=0x100000
  c include: ..\;..\..\..\..\ThirdParty\ml-embedded-evaluation-kit\source\application\api\common\include;..\..\..\..\ThirdParty\ml-embedded-evaluation-kit\source\log\include;..\..\..\..\ThirdParty\ml-embedded-evaluation-kit\source\math\include;..\..\..\..\ThirdParty\ml-embedded-evaluation-kit\source\application\main\include;..\..\..\..\ThirdParty\ml-embedded-evaluation-kit\source\profiler\include;..\..\..\..\Library\CMSIS\Core\Include;..\..\..\..\Library\Device\Nuvoton\M55M1\Include;..\Device\include;..\..\..\..\Library\StdDriver\inc;..\..\..\..\Library\StdDriver\inc\npu;..\..\..\..\ThirdParty\FatFs\source;..\..\..\..\Library\CMSIS\NN\Include;..\..\..\..\Library\CMSIS\DSP\Include;..\..\..\..\ThirdParty\tflite_micro;..\..\..\..\ThirdParty\tflite_micro\_deps\tensorflow-flatbuffers-src\include;..\..\..\..\ThirdParty\tflite_micro\_deps\tensorflow-gemlowp-src;..\..\..\..\ThirdParty\ml-embedded-evaluation-kit\source\math;..\Model\include;..\NPU\include;..\ProfilerCounter\include
  asm misc: -DNVT_VECTOR_ON_FLASH -DTF_LITE_STATIC_MEMORY -DARM_MATH_DSP -DARM_NPU -DACTIVATION_BUF_SZ=0x100000
  memory RVCT4: ROM 0x10000000 size 0x200000
  memory RVCT5: ROM 0x0 size 0x200000
  memory RVCT9: RAM 0x30000000 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: M55M1.scatter
  group Application
    ../: BoardInit.cpp main.cpp ModelFileReader.c
  group ArmMLApi
    ../../../../ThirdParty/ml-embedded-evaluation-kit/source/application/api/common/source/: Model.cc TensorFlowLiteMicro.cc
    ../../../../ThirdParty/ml-embedded-evaluation-kit/source/profiler/: Profiler.cc
    ../../../../ThirdParty/ml-embedded-evaluation-kit/source/math/: PlatformMath.cc
  group CMSIS
    ../../../../Library/Device/Nuvoton/M55M1/Source/: startup_M55M1.c system_M55M1.c
  group Device
    ../../../../Library/Storage/: diskio_SDH.c
    ../Device/HyperRAM/: hyperram_code.c
    ../Device/SDCard/: sdglue.c
  group Driver
    ../../../../Library/StdDriver/src/: clk.c gpio.c retarget.c sdh.c spim_hyper.c sys.c uart.c
    ../../../../Library/StdDriver/src/npu/: ethosu_device_u55_u65.c ethosu_driver.c ethosu_pmu.c
  group FatFs
    ../../../../ThirdParty/FatFs/source/: ff.c ffunicode.c
  group Lib
    ../../../../Library/CMSIS/Lib/KEIL/: cmsis_dsp.lib cmsis_nn.lib
    ../../../../ThirdParty/tflite_micro/Lib/: tflu.lib
  group Model
    ../Model/: NN_Model_INT8.tflite.cpp NNModel.cpp
  group NPU
    ../NPU/: ethosu_cpu_cache.c ethosu_npu_init.c ethosu_profiler.c
  group ProfilerCounter
    ../ProfilerCounter/: pmu_counter.c
  group Pattern
    ../Pattern/: SOH_test_data.h
