# Keil uVision project AnomalyDetection.uvprojx, settings and files
target AnomalyDetection (6230000::V6.23::ARMCLANG)
  device: M55M1H2LJAE Nuvoton
  pack: Nuvoton.NuMicroM55_DFP.1.0.1
  cpu: IRAM(0x20100000,0x150000) IRAM2(0x30100000,0x150000) IROM(0x00100000,0x200000) IROM2(0x10100000,0x200000) CPUTYPE("Cortex-M55") FPU3(DFPU) DSP TZ MVE(FP) CLOCK(12000000) ESEL ELITTLE
  output: AnomalyDetection
  c flags: Optim=3 OneElfS=1 v6Lang=5 v6LangP=6 wLevel=3
  c define: ARM_MATH_DSP,ARM_MATH_HELIUM,TF_LITE_STATIC_MEMORY,CMSIS_NN, ARM_NPU
  c include: ..\..\..\..\Library\StdDriver\inc;..\..\..\..\Library\StdDriver\inc\npu;..\..\..\..\Library\CMSIS\Core\Include;..\..\..\..\Library\Device\Nuvoton\M55M1\Include;..\..\..\..\Library\CMSIS\NN\Include;..\..\..\..\Library\CMSIS\DSP\Include;..\..\..\..\ThirdParty\tflite_micro;..\..\..\..\ThirdParty\tflite_micro\_deps\tensorflow-flatbuffers-src\include;..\..\..\..\ThirdParty\tflite_micro\_deps\tensorflow-gemlowp-src;..\..\..\..\ThirdParty\ml-embedded-evaluation-kit\source\application\api\common\include;..\..\..\..\ThirdParty\ml-embedded-evaluation-kit\source\application\main\include;..\..\..\..\ThirdParty\ml-embedded-evaluation-kit\source\log\include;..\..\..\..\ThirdParty\ml-embedded-evaluation-kit\source\math\include;..\..\..\..\ThirdParty\ml-embedded-evaluation-kit\source\profiler\include;..\NN\CNN\;..\NNClassify\;..\NPU\include;..\Generated\;..\NN\;..\
  memory RVCT4: ROM 0x100000 size 0x200000
  memory RVCT5: ROM 0x10100000 size 0x200000
  memory RVCT9: RAM 0x20100000 size 0x150000
  memory RVCT10: RAM 0x30100000 size 0x150000
  scatter file: .\M55M1.scatter
  group CMSIS
    ../../../../Library/Device/Nuvoton/M55M1/Source/: startup_M55M1.c system_M55M1.c
  group Generated
    ../Generated/: ad_imu_model_quant_vela_H256.tflite.cpp
  group Library
    ../../../../ThirdParty/tflite_micro/Lib/: tflu.lib
    ../../../../Library/CMSIS/Lib/KEIL/: cmsis_dsp.lib cmsis_nn.lib
  group Classify
    ../NNClassify/: MainClassify.cpp
  group NN
    ../NN/: Model.cpp
    ../NN/CNN/: CnnModel.cpp
  group NPU
    ../../../../Library/StdDriver/src/npu/: ethosu_device_u55_u65.c ethosu_driver.c ethosu_pmu.c
  group Driver
    ../../../../Library/StdDriver/src/: retarget.c uart.c clk.c sys.c gpio.c ebi.c epwm.c pdma.c i2c.c timer.c lpi2c.c
    ../NPU/: ethosu_npu_init.c ethosu_profiler.c ethosu_cpu_cache.c
  group User
    ../: main.cpp MPU6500.c mpu_config_M55M1.h
