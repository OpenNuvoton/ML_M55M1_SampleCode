# Keil uVision project CMSIS_DSP.uvprojx, settings and files
target Release (6190000::V6.19::ARMCLANG)
  device: ARMCM55 ARM
  pack: ARM.Cortex_DFP.1.1.0
  cpu: IRAM(0x30000000,0x00020000) IRAM2(0x20000000,0x00020000) IROM(0x10000000,0x00200000) IROM2(0x00000000,0x00200000) CPUTYPE("Cortex-M55") FPU3(DFPU) DSP TZ MVE(FP) CLOCK(12000000) ESEL ELITTLE
  output: cmsis_dsp (library)
  AfterMake: xcopy /Y .\Objects\cmsis_dsp.lib ..\
  c flags: Optim=3 OneElfS=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: ARM_MATH_DSP, ARM_MATH_LOOPUNROLL, ARM_MATH_HELIUM
  c include: ..\..\..\..\..\edge-impulse-sdk\CMSIS\DSP\Include;..\..\..\..\..\edge-impulse-sdk\CMSIS\DSP\PrivateInclude;..\..\..\..\..\edge-impulse-sdk\CMSIS\Core\Include;..\..\..\..\..\
  memory RVCT4: ROM 0x10000000 size 0x200000
  memory RVCT5: ROM 0x0 size 0x200000
  memory RVCT9: RAM 0x30000000 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  group BasicMathFunctions
    ../../../../../edge-impulse-sdk/CMSIS/DSP/Source/BasicMathFunctions/: arm_abs_f16.c arm_abs_f32.c arm_abs_f64.c arm_abs_q7.c arm_abs_q15.c arm_abs_q31.c arm_add_f16.c arm_add_f32.c arm_add_f64.c arm_add_q7.c arm_add_q15.c arm_add_q31.c arm_and_u8.c arm_and_u16.c arm_and_u32.c arm_clip_f16.c arm_clip_f32.c arm_clip_q7.c arm_clip_q15.c arm_clip_q31.c arm_dot_prod_f16.c arm_dot_prod_f32.c arm_dot_prod_f64.c arm_dot_prod_q7.c arm_dot_prod_q15.c arm_dot_prod_q31.c arm_mult_f16.c arm_mult_f32.c arm_mult_f64.c arm_mult_q7.c arm_mult_q15.c arm_mult_q31.c arm_negate_f16.c arm_negate_f32.c arm_negate_f64.c arm_negate_q7.c arm_negate_q15.c arm_negate_q31.c arm_not_u8.c arm_not_u16.c arm_not_u32.c arm_offset_f16.c arm_offset_f32.c arm_offset_f64.c arm_offset_q7.c arm_offset_q15.c arm_offset_q31.c arm_or_u8.c arm_or_u16.c arm_or_u32.c arm_scale_f16.c arm_scale_f32.c arm_scale_f64.c arm_scale_q7.c arm_scale_q15.c arm_scale_q31.c arm_shift_q7.c arm_shift_q15.c arm_shift_q31.c arm_sub_f16.c arm_sub_f32.c arm_sub_f64.c arm_sub_q7.c arm_sub_q15.c arm_sub_q31.c arm_xor_u8.c arm_xor_u16.c arm_xor_u32.c
  group BayesFunctions
    ../../../../../edge-impulse-sdk/CMSIS/DSP/Source/BayesFunctions/: arm_gaussian_naive_bayes_predict_f16.c arm_gaussian_naive_bayes_predict_f32.c
  group CommonTables
    ../../../../../edge-impulse-sdk/CMSIS/DSP/Source/CommonTables/: arm_common_tables.c arm_common_tables_f16.c arm_const_structs.c arm_const_structs_f16.c arm_mve_tables.c arm_mve_tables_f16.c
  group ComplexMathFunctions
    ../../../../../edge-impulse-sdk/CMSIS/DSP/Source/ComplexMathFunctions/: arm_cmplx_conj_f16.c arm_cmplx_conj_f32.c arm_cmplx_conj_q15.c arm_cmplx_conj_q31.c arm_cmplx_dot_prod_f16.c arm_cmplx_dot_prod_f32.c arm_cmplx_dot_prod_q15.c arm_cmplx_dot_prod_q31.c arm_cmplx_mag_f16.c arm_cmplx_mag_f32.c arm_cmplx_mag_f64.c arm_cmplx_mag_fast_q15.c arm_cmplx_mag_q15.c arm_cmplx_mag_q31.c arm_cmplx_mag_squared_f16.c arm_cmplx_mag_squared_f32.c arm_cmplx_mag_squared_f64.c arm_cmplx_mag_squared_q15.c arm_cmplx_mag_squared_q31.c arm_cmplx_mult_cmplx_f16.c arm_cmplx_mult_cmplx_f32.c arm_cmplx_mult_cmplx_f64.c arm_cmplx_mult_cmplx_q15.c arm_cmplx_mult_cmplx_q31.c arm_cmplx_mult_real_f16.c arm_cmplx_mult_real_f32.c arm_cmplx_mult_real_q15.c arm_cmplx_mult_real_q31.c
  group FastMathFunctions
    ../../../../../edge-impulse-sdk/CMSIS/DSP/Source/FastMathFunctions/: arm_atan2_f16.c arm_atan2_f32.c arm_atan2_q15.c arm_atan2_q31.c arm_cos_f32.c arm_cos_q15.c arm_cos_q31.c arm_divide_q15.c arm_divide_q31.c arm_sin_f32.c arm_sin_q15.c arm_sin_q31.c arm_sqrt_q15.c arm_sqrt_q31.c arm_vexp_f16.c arm_vexp_f32.c arm_vexp_f64.c arm_vinverse_f16.c arm_vlog_f16.c arm_vlog_f32.c arm_vlog_f64.c arm_vlog_q15.c arm_vlog_q31.c
  group MatrixFunctions
    ../../../../../edge-impulse-sdk/CMSIS/DSP/Source/MatrixFunctions/: arm_householder_f16.c arm_householder_f32.c arm_householder_f64.c arm_mat_add_f16.c arm_mat_add_f32.c arm_mat_add_q15.c arm_mat_add_q31.c arm_mat_cholesky_f16.c arm_mat_cholesky_f32.c arm_mat_cholesky_f64.c arm_mat_cmplx_mult_f16.c arm_mat_cmplx_mult_f32.c arm_mat_cmplx_mult_q15.c arm_mat_cmplx_mult_q31.c arm_mat_cmplx_trans_f16.c arm_mat_cmplx_trans_f32.c arm_mat_cmplx_trans_q15.c arm_mat_cmplx_trans_q31.c arm_mat_init_f16.c arm_mat_init_f32.c arm_mat_init_q15.c arm_mat_init_q31.c arm_mat_inverse_f16.c arm_mat_inverse_f32.c arm_mat_inverse_f64.c arm_mat_ldlt_f32.c arm_mat_ldlt_f64.c arm_mat_mult_f16.c arm_mat_mult_f32.c arm_mat_mult_f64.c arm_mat_mult_fast_q15.c arm_mat_mult_fast_q31.c arm_mat_mult_opt_q31.c arm_mat_mult_q7.c arm_mat_mult_q15.c arm_mat_mult_q31.c arm_mat_qr_f16.c arm_mat_qr_f32.c arm_mat_qr_f64.c arm_mat_scale_f16.c arm_mat_scale_f32.c arm_mat_scale_q15.c arm_mat_scale_q31.c arm_mat_solve_lower_triangular_f16.c arm_mat_solve_lower_triangular_f32.c arm_mat_solve_lower_triangular_f64.c arm_mat_solve_upper_triangular_f16.c arm_mat_solve_upper_triangular_f32.c arm_mat_solve_upper_triangular_f64.c arm_mat_sub_f16.c arm_mat_sub_f32.c arm_mat_sub_f64.c arm_mat_sub_q15.c arm_mat_sub_q31.c arm_mat_trans_f16.c arm_mat_trans_f32.c arm_mat_trans_f64.c arm_mat_trans_q7.c arm_mat_trans_q15.c arm_mat_trans_q31.c arm_mat_vec_mult_f16.c arm_mat_vec_mult_f32.c arm_mat_vec_mult_q7.c arm_mat_vec_mult_q15.c arm_mat_vec_mult_q31.c
  group StatisticsFunctions
    ../../../../../edge-impulse-sdk/CMSIS/DSP/Source/StatisticsFunctions/: arm_absmax_f16.c arm_absmax_f32.c arm_absmax_f64.c arm_absmax_no_idx_f16.c arm_absmax_no_idx_f32.c arm_absmax_no_idx_f64.c arm_absmax_no_idx_q7.c arm_absmax_no_idx_q15.c arm_absmax_no_idx_q31.c arm_absmax_q7.c arm_absmax_q15.c arm_absmax_q31.c arm_absmin_f16.c arm_absmin_f32.c arm_absmin_f64.c arm_absmin_no_idx_f16.c arm_absmin_no_idx_f32.c arm_absmin_no_idx_f64.c arm_absmin_no_idx_q7.c arm_absmin_no_idx_q15.c arm_absmin_no_idx_q31.c arm_absmin_q7.c arm_absmin_q15.c arm_absmin_q31.c arm_accumulate_f16.c arm_accumulate_f32.c arm_accumulate_f64.c arm_entropy_f16.c arm_entropy_f32.c arm_entropy_f64.c arm_kullback_leibler_f16.c arm_kullback_leibler_f32.c arm_kullback_leibler_f64.c arm_logsumexp_dot_prod_f16.c arm_logsumexp_dot_prod_f32.c arm_logsumexp_f16.c arm_logsumexp_f32.c arm_max_f16.c arm_max_f32.c arm_max_f64.c arm_max_no_idx_f16.c arm_max_no_idx_f32.c arm_max_no_idx_f64.c arm_max_no_idx_q7.c arm_max_no_idx_q15.c arm_max_no_idx_q31.c arm_max_q7.c arm_max_q15.c arm_max_q31.c arm_mean_f16.c arm_mean_f32.c arm_mean_f64.c arm_mean_q7.c arm_mean_q15.c arm_mean_q31.c arm_min_f16.c arm_min_f32.c arm_min_f64.c arm_min_no_idx_f16.c arm_min_no_idx_f32.c arm_min_no_idx_f64.c arm_min_no_idx_q7.c arm_min_no_idx_q15.c arm_min_no_idx_q31.c arm_min_q7.c arm_min_q15.c arm_min_q31.c arm_mse_f16.c arm_mse_f32.c arm_mse_f64.c arm_mse_q7.c arm_mse_q15.c arm_mse_q31.c arm_power_f16.c arm_power_f32.c arm_power_f64.c arm_power_q7.c arm_power_q15.c arm_power_q31.c arm_rms_f16.c arm_rms_f32.c arm_rms_q15.c arm_rms_q31.c arm_std_f16.c arm_std_f32.c arm_std_f64.c arm_std_q15.c arm_std_q31.c arm_var_f16.c arm_var_f32.c arm_var_f64.c arm_var_q15.c arm_var_q31.c
  group SupportFunctions
    ../../../../../edge-impulse-sdk/CMSIS/DSP/Source/SupportFunctions/: arm_barycenter_f16.c arm_barycenter_f32.c arm_bitonic_sort_f32.c arm_bubble_sort_f32.c arm_copy_f16.c arm_copy_f32.c arm_copy_f64.c arm_copy_q7.c arm_copy_q15.c arm_copy_q31.c arm_f16_to_float.c arm_f16_to_q15.c arm_fill_f16.c arm_fill_f32.c arm_fill_f64.c arm_fill_q7.c arm_fill_q15.c arm_fill_q31.c arm_float_to_f16.c arm_float_to_q7.c arm_float_to_q15.c arm_float_to_q31.c arm_heap_sort_f32.c arm_insertion_sort_f32.c arm_merge_sort_f32.c arm_merge_sort_init_f32.c arm_q7_to_float.c arm_q7_to_q15.c arm_q7_to_q31.c arm_q15_to_f16.c arm_q15_to_float.c arm_q15_to_q7.c arm_q15_to_q31.c arm_q31_to_float.c arm_q31_to_q7.c arm_q31_to_q15.c arm_quick_sort_f32.c arm_selection_sort_f32.c arm_sort_f32.c arm_sort_init_f32.c arm_weighted_sum_f16.c arm_weighted_sum_f32.c
  group TransformFunctions
    ../../../../../edge-impulse-sdk/CMSIS/DSP/Source/TransformFunctions/: arm_bitreversal.c arm_bitreversal_f16.c arm_bitreversal2.c arm_cfft_f16.c arm_cfft_f32.c arm_cfft_f64.c arm_cfft_init_f16.c arm_cfft_init_f32.c arm_cfft_init_f64.c arm_cfft_init_q15.c arm_cfft_init_q31.c arm_cfft_q15.c arm_cfft_q31.c arm_cfft_radix2_f16.c arm_cfft_radix2_f32.c arm_cfft_radix2_init_f16.c arm_cfft_radix2_init_f32.c arm_cfft_radix2_init_q15.c arm_cfft_radix2_init_q31.c arm_cfft_radix2_q15.c arm_cfft_radix2_q31.c arm_cfft_radix4_f16.c arm_cfft_radix4_f32.c arm_cfft_radix4_init_f16.c arm_cfft_radix4_init_f32.c arm_cfft_radix4_init_q15.c arm_cfft_radix4_init_q31.c arm_cfft_radix4_q15.c arm_cfft_radix4_q31.c arm_cfft_radix8_f16.c arm_cfft_radix8_f32.c arm_dct4_f32.c arm_dct4_init_f32.c arm_dct4_init_q15.c arm_dct4_init_q31.c arm_dct4_q15.c arm_dct4_q31.c arm_mfcc_f16.c arm_mfcc_f32.c arm_mfcc_init_f16.c arm_mfcc_init_f32.c arm_mfcc_init_q15.c arm_mfcc_init_q31.c arm_mfcc_q15.c arm_mfcc_q31.c arm_rfft_f32.c arm_rfft_fast_f16.c arm_rfft_fast_f32.c arm_rfft_fast_f64.c arm_rfft_fast_init_f16.c arm_rfft_fast_init_f32.c arm_rfft_fast_init_f64.c arm_rfft_init_f32.c arm_rfft_init_q15.c arm_rfft_init_q31.c arm_rfft_q15.c arm_rfft_q31.c
