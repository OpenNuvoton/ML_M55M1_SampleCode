# Keil uVision project tflite_micro.uvprojx, settings and files
target Release (6190000::V6.19::ARMCLANG)
  device: ARMCM55 ARM
  pack: ARM.Cortex_DFP.1.1.0
  cpu: IRAM(0x30000000,0x00020000) IRAM2(0x20000000,0x00020000) IROM(0x10000000,0x00200000) IROM2(0x00000000,0x00200000) CPUTYPE("Cortex-M55") FPU3(DFPU) DSP TZ MVE(FP) CLOCK(12000000) ESEL ELITTLE
  output: tflu (library)
  AfterMake: xcopy /Y .\Objects\tflu.lib ..\
  c flags: Optim=3 OneElfS=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: CMSIS_NN, ETHOSU, FLATBUFFERS_LOCALE_INDEPENDENT=0, TF_LITE_STATIC_MEMORY, NDEBUG, EI_ETHOS
  c include: ..\..\;..\..\edge-impulse-sdk\porting\ethos-core-driver\include
  memory RVCT4: ROM 0x10000000 size 0x200000
  memory RVCT5: ROM 0x0 size 0x200000
  memory RVCT9: RAM 0x30000000 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  group micro-kernels-ethos_u
    ../../edge-impulse-sdk/tensorflow/lite/micro/kernels/: ethosu.cc
  group micro-memory_planner
    ../../edge-impulse-sdk/tensorflow/lite/micro/memory_planner/: greedy_memory_planner.cc linear_memory_planner.cc non_persistent_buffer_planner_shim.cc
  group core-api
    ../../edge-impulse-sdk/tensorflow/lite/core/api/: common.cc error_reporter.cc flatbuffer_conversions.cc op_resolver.cc tensor_utils.cc
  group kernels
    ../../edge-impulse-sdk/tensorflow/lite/kernels/: kernel_util_lite.cc
  group kernels-internal
    ../../edge-impulse-sdk/tensorflow/lite/kernels/internal/: portable_tensor_utils.cc quantization_util.cc reference_portable_tensor_utils.cc tensor_utils.cc
  group c
    ../../edge-impulse-sdk/tensorflow/lite/c/: common.c
  group micro-kernels
    ../../edge-impulse-sdk/tensorflow/lite/micro/kernels/: activations.cc activations_common.cc add.cc add_common.cc add_n.cc arg_min_max.cc assign_variable.cc batch_matmul.cc batch_to_space_nd.cc broadcast_args.cc broadcast_to.cc call_once.cc cast.cc ceil.cc circular_buffer.cc circular_buffer_common.cc comparisons.cc complex_abs.cc concatenation.cc conv.cc conv_common.cc cumsum.cc depth_to_space.cc depthwise_conv.cc depthwise_conv_common.cc dequantize.cc dequantize_common.cc detection_postprocess.cc div.cc elementwise.cc elu.cc exp.cc expand_dims.cc fill.cc floor.cc floor_div.cc floor_mod.cc fully_connected.cc fully_connected_common.cc gather.cc gather_nd.cc hard_swish.cc hard_swish_common.cc if.cc kernel_runner.cc kernel_util_micro.cc l2_pool_2d.cc l2norm.cc leaky_relu.cc leaky_relu_common.cc log_softmax.cc logical.cc logical_common.cc logistic.cc logistic_common.cc lstm_eval.cc maximum_minimum.cc micro_tensor_utils.cc mirror_pad.cc mli_interface.cc mli_slicers.cc mul.cc mul_common.cc neg.cc pack.cc pad.cc pooling.cc pooling_common.cc prelu.cc prelu_common.cc quantize.cc quantize_common.cc read_variable.cc real.cc reduce.cc reduce_common.cc reshape.cc resize_bilinear.cc resize_nearest_neighbor.cc rfft2d.cc round.cc scatter_nd.cc scratch_buf_mgr.cc scratch_buffers.cc select.cc shape.cc slice.cc softmax.cc softmax_common.cc space_to_batch_nd.cc space_to_depth.cc split.cc split_v.cc squared_difference.cc squeeze.cc strided_slice.cc sub.cc sub_common.cc svdf.cc svdf_common.cc tanh.cc tile.cc topk_v2.cc transpose.cc transpose_conv.cc tree_ensemble_classifier.cc unidirectional_sequence_lstm.cc unpack.cc var_handle.cc while.cc zeros_like.cc
  group micro
    ../../edge-impulse-sdk/tensorflow/lite/micro/: all_ops_resolver.cc fake_micro_context.cc flatbuffer_conversions_bridge.cc flatbuffer_utils.cc memory_helpers.cc micro_allocation_info.cc micro_allocator.cc micro_context.cc micro_error_reporter.cc micro_graph.cc micro_interpreter.cc micro_log.cc micro_profiler.cc micro_resource_variable.cc micro_string.cc micro_time.cc micro_utils.cc mock_micro_graph.cc non_persistent_arena_buffer_allocator.cc op_resolver_bridge.cc persistent_arena_buffer_allocator.cc recording_micro_allocator.cc recording_single_arena_buffer_allocator.cc schema_utils.cc single_arena_buffer_allocator.cc system_setup.cc test_helper_custom_ops.cc test_helpers.cc
