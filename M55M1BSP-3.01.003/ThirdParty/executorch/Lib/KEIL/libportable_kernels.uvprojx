# Keil uVision project libportable_kernels.uvprojx, settings and files
target Release (6230000::V6.23::ARMCLANG)
  device: M55M1H2LJAE Nuvoton
  pack: Nuvoton.NuMicroM55_DFP.3.1.3
  cpu: IRAM(0x20100000,0x150000) IRAM2(0x30100000,0x150000) IROM(0x00100000,0x200000) IROM2(0x10100000,0x200000) CPUTYPE("Cortex-M55") FPU3(DFPU) DSP TZ MVE(FP) CLOCK(12000000) ESEL ELITTLE
  output: libportable_kernels (library)
  AfterMake: xcopy /Y .\Objects\libportable_kernels.lib ..\
  c flags: Optim=7 OneElfS=1 v6Lang=5 v6LangP=8 wLevel=3
  c define: NDEBUG, ET_ENABLE_PROGRAM_VERIFICATION=0, ET_MIN_LOG=Info, C10_USING_CUSTOM_GENERATED_MACROS
  c include: ..\..\..\;..\..\..\..\Library\StdDriver\inc\npu;..\..\third-party\flatbuffers\include;..\..\runtime\core\portable_type\c10
  memory RVCT4: ROM 0x100000 size 0x200000
  memory RVCT5: ROM 0x10100000 size 0x200000
  memory RVCT9: RAM 0x20100000 size 0x150000
  memory RVCT10: RAM 0x30100000 size 0x150000
  group libportable_kernels
    ../../kernels/portable/cpu/: op__clone_dim_order.cpp op__empty_dim_order.cpp op__to_dim_order_copy.cpp op_abs.cpp op_acos.cpp op_acosh.cpp op_add.cpp op_addmm.cpp op_alias_copy.cpp op_allclose.cpp op_amax.cpp op_amin.cpp op_any.cpp op_arange.cpp op_argmax.cpp op_argmin.cpp op_as_strided_copy.cpp op_asin.cpp op_asinh.cpp op_atan.cpp op_atan2.cpp op_atanh.cpp op_avg_pool2d.cpp op_bitwise_and.cpp op_bitwise_not.cpp op_bitwise_or.cpp op_bitwise_xor.cpp op_bmm.cpp op_cat.cpp op_cdist_forward.cpp op_ceil.cpp op_clamp.cpp op_clone.cpp op_constant_pad_nd.cpp op_convolution.cpp op_copy.cpp op_cos.cpp op_cosh.cpp op_cumsum.cpp op_detach_copy.cpp op_diagonal_copy.cpp op_div.cpp op_elu.cpp op_embedding.cpp op_empty.cpp op_eq.cpp op_erf.cpp op_exp.cpp op_expand_copy.cpp op_expm1.cpp op_fill.cpp op_flip.cpp op_floor.cpp op_floor_divide.cpp op_fmod.cpp op_full.cpp op_full_like.cpp op_gather.cpp op_ge.cpp op_gelu.cpp op_glu.cpp op_gt.cpp op_hardtanh.cpp op_index.cpp op_index_put.cpp op_index_select.cpp op_isinf.cpp op_isnan.cpp op_le.cpp op_leaky_relu.cpp op_lift_fresh_copy.cpp op_linear_scratch_example.cpp op_log.cpp op_log10.cpp op_log1p.cpp op_log2.cpp op_log_softmax.cpp op_logical_and.cpp op_logical_not.cpp op_logical_or.cpp op_logical_xor.cpp op_logit.cpp op_lt.cpp op_masked_fill.cpp op_masked_scatter.cpp op_masked_select.cpp op_max.cpp op_max_pool2d_with_indices.cpp op_max_pool2d_with_indices_backward.cpp op_maximum.cpp op_mean.cpp op_min.cpp op_minimum.cpp op_mm.cpp op_mul.cpp op_narrow_copy.cpp op_native_batch_norm.cpp op_native_dropout.cpp op_native_group_norm.cpp op_native_layer_norm.cpp op_ne.cpp op_neg.cpp op_nonzero.cpp op_ones.cpp op_pdist_forward.cpp op_permute_copy.cpp op_pixel_shuffle.cpp op_pixel_unshuffle.cpp op_pow.cpp op_prod.cpp op_rand.cpp op_randn.cpp op_reciprocal.cpp op_reflection_pad1d.cpp op_reflection_pad2d.cpp op_reflection_pad3d.cpp op_relu.cpp op_remainder.cpp op_repeat.cpp op_repeat_interleave.cpp op_replication_pad1d.cpp op_replication_pad2d.cpp op_replication_pad3d.cpp op_roll.cpp op_round.cpp op_rsqrt.cpp op_rsub.cpp op_scalar_tensor.cpp op_scatter_add.cpp op_select_copy.cpp op_select_scatter.cpp op_sigmoid.cpp op_sign.cpp op_sin.cpp op_sinh.cpp op_slice_copy.cpp op_slice_scatter.cpp op_softmax.cpp op_split_copy.cpp op_split_with_sizes_copy.cpp op_sqrt.cpp op_squeeze_copy.cpp op_stack.cpp op_sub.cpp op_sum.cpp op_t_copy.cpp op_tan.cpp op_tanh.cpp op_to_copy.cpp op_topk.cpp op_transpose_copy.cpp op_tril.cpp op_trunc.cpp op_unbind_copy.cpp op_unfold_copy.cpp op_unsqueeze_copy.cpp op_upsample_bilinear2d.cpp op_upsample_bilinear2d_aa.cpp op_upsample_nearest2d.cpp op_var.cpp op_view_copy.cpp op_where.cpp op_zeros.cpp
    ../../kernels/portable/cpu/pattern/: unary_ufunc_realhbbf16_to_bool.cpp unary_ufunc_realhbbf16_to_floathbf16.cpp unary_ufunc_realhbf16.cpp
    ../../kernels/portable/cpu/util/: activation_ops_util.cpp advanced_index_util.cpp broadcast_util.cpp copy_ops_util.cpp delinearize_index.cpp distance_util.cpp dtype_util.cpp index_util.cpp kernel_ops_util.cpp matmul_ops_util.cpp normalization_ops_util.cpp padding_util.cpp reduce_util.cpp repeat_util.cpp select_copy_util.cpp slice_util.cpp stack_util.cpp upsample_util.cpp
