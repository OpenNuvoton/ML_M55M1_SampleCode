# Keil uVision project libquantized_ops_lib.uvprojx, settings and files
target Release (6230000::V6.23::ARMCLANG)
  device: ARMCM55 ARM
  pack: ARM.Cortex_DFP.1.1.0
  cpu: IRAM(0x30000000,0x00020000) IRAM2(0x20000000,0x00020000) IROM(0x10000000,0x00200000) IROM2(0x00000000,0x00200000) CPUTYPE("Cortex-M55") FPU3(DFPU) DSP TZ MVE(FP) CLOCK(12000000) ESEL ELITTLE
  output: libquantized_ops_lib (library)
  c flags: Optim=3 OneElfS=1 v6Lang=5 v6LangP=8 wLevel=3
  c define: NDEBUG, ET_ENABLE_PROGRAM_VERIFICATION=0, ET_MIN_LOG=Info, C10_USING_CUSTOM_GENERATED_MACROS
  c include: ..\..\..\;..\..\..\..\Library\StdDriver\inc\npu;..\..\third-party\flatbuffers\include;..\..\runtime\core\portable_type\c10
  memory RVCT4: ROM 0x10000000 size 0x200000
  memory RVCT5: ROM 0x0 size 0x200000
  memory RVCT9: RAM 0x30000000 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  group libquantized_ops_lib
    ../../_prebuilt/kernels/quantized/: RegisterCodegenUnboxedKernelsEverything.cpp
