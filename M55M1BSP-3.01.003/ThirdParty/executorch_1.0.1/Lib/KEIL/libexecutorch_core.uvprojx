# Keil uVision project libexecutorch_core.uvprojx, settings and files
target Release (6230000::V6.23::ARMCLANG)
  device: M55M1H2LJAE Nuvoton
  pack: Nuvoton.NuMicroM55_DFP.3.1.3
  cpu: IRAM(0x20100000,0x150000) IRAM2(0x30100000,0x150000) IROM(0x00100000,0x200000) IROM2(0x10100000,0x200000) CPUTYPE("Cortex-M55") FPU3(DFPU) DSP TZ MVE(FP) CLOCK(12000000) ESEL ELITTLE
  output: libexecutorch_core (library)
  AfterMake: xcopy /Y .\Objects\libexecutorch_core.lib ..\
  c flags: Optim=3 OneElfS=1 v6Lang=5 v6LangP=8 wLevel=3
  c define: NDEBUG, ET_ENABLE_PROGRAM_VERIFICATION=0, ET_MIN_LOG=Info, C10_USING_CUSTOM_GENERATED_MACROS
  c include: ..\..\..\;..\..\..\..\Library\StdDriver\inc\npu;..\..\third-party\flatbuffers\include;..\..\runtime\core\portable_type\c10;..\..\_prebuilt\schema\include
  memory RVCT4: ROM 0x100000 size 0x200000
  memory RVCT5: ROM 0x10100000 size 0x200000
  memory RVCT9: RAM 0x20100000 size 0x150000
  memory RVCT10: RAM 0x30100000 size 0x150000
  group libexecutorch_core
    ../../runtime/backend/: interface.cpp
    ../../runtime/core/: evalue.cpp tag.cpp tensor_layout.cpp
    ../../runtime/core/exec_aten/util/: tensor_shape_to_c_string.cpp tensor_util_portable.cpp
    ../../runtime/core/portable_type/: tensor_impl.cpp
    ../../runtime/executor/: method.cpp method_meta.cpp program.cpp pte_data_map.cpp tensor_parser_exec_aten.cpp tensor_parser_portable.cpp
    ../../runtime/kernel/: operator_registry.cpp
    ../../runtime/platform/: abort.cpp log.cpp platform.cpp profiler.cpp runtime.cpp
    ../../schema/: extended_header.cpp
