# Keil uVision project NN_ExecuTorch.uvprojx, settings and files
target NN_ExecuTorch (6230000::V6.23::ARMCLANG)
  device: M55M1H2LJAE Nuvoton
  pack: Nuvoton.NuMicroM55_DFP.3.1.3
  cpu: IRAM(0x20100000,0x150000) IRAM2(0x30100000,0x150000) IROM(0x00100000,0x200000) IROM2(0x10100000,0x200000) CPUTYPE("Cortex-M55") FPU3(DFPU) DSP TZ MVE(FP) CLOCK(12000000) ESEL ELITTLE
  output: NN_ExecuTorch
  AfterMake: fromelf --bin ".\Objects\@L.axf" --output=release
  c flags: Optim=1 OneElfS=1 v6Lang=5 v6LangP=8 wLevel=3
  c define: NVT_VECTOR_ON_FLASH, ARM_NPU, C10_USING_CUSTOM_GENERATED_MACROS
  c include: ..\..\..\..\Library\CMSIS\Core\Include;..\..\..\..\Library\Device\Nuvoton\M55M1\Include;..\..\..\..\Library\StdDriver\inc;..\..\..\..\Library\StdDriver\inc\npu;..\;..\NPU\include;..\Device\include;..\ProfilerCounter\include;..\..\..\..\ThirdParty\executorch\_prebuilt\kernels;..\..\..\..\ThirdParty;..\..\..\..\ThirdParty\executorch\runtime\core\portable_type\c10;..\..\..\..\ThirdParty\FatFs\source;..\..\..\..\ThirdParty\ml-embedded-evaluation-kit\source\profiler\include;..\..\..\..\ThirdParty\ml-embedded-evaluation-kit\source\log\include;..\..\..\..\ThirdParty\executorch\_prebuilt\backends
  memory RVCT4: ROM 0x100000 size 0x200000
  memory RVCT5: ROM 0x10100000 size 0x200000
  memory RVCT9: RAM 0x20100000 size 0x150000
  memory RVCT10: RAM 0x30100000 size 0x150000
  scatter file: .\M55M1.scatter
  group CMSIS
    ../../../../Library/Device/Nuvoton/M55M1/Source/: startup_M55M1.c system_M55M1.c
  group Driver
    ../../../../Library/StdDriver/src/: uart.c retarget.c ccap.c clk.c spim.c sys.c gpio.c spim_hyper.c sdh.c
  group Lib
    ../../../../ThirdParty/executorch/Lib/: libexecutorch.lib libexecutorch_core.lib libexecutorch_delegate_ethos_u.lib libportable_kernels.lib libquantized_kernels.lib libcortex_m_kernels.lib
  group ethosu
    ../../../../Library/StdDriver/src/npu/: ethosu_device_u55_u65.c ethosu_driver.c ethosu_pmu.c
  group Application
    ../: main.cpp BoardInit.cpp executorch_platform.cpp RegisterNativeKernels.cpp RegisterEthosUBackend.cpp ModelFileReader.c
  group Device
    ../Device/HyperRAM/: hyperram_code.c
    ../Device/SDCard/: sdglue.c
    ../../../../Library/Storage/: diskio_SDH.c
  group NPU
    ../NPU/: ethosu_cpu_cache.c ethosu_npu_init.c ethosu_profiler.c
  group extension
    ../../../../ThirdParty/executorch/extension/runner_util/: inputs.cpp inputs_portable.cpp
  group ProfilerCounter
    ../ProfilerCounter/: pmu_counter.c
  group FatFs
    ../../../../ThirdParty/FatFs/source/: ff.c ffunicode.c
  group ArmMLApi
    ../../../../ThirdParty/ml-embedded-evaluation-kit/source/profiler/: Profiler.cc
