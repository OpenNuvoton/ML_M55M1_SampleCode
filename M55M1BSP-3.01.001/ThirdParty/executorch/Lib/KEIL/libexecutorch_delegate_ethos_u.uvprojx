# Keil uVision project libexecutorch_delegate_ethos_u.uvprojx, settings and files
target Release (6230000::V6.23::ARMCLANG)
  device: M55M1H2LJAE Nuvoton
  pack: Nuvoton.NuMicroM55_DFP.1.0.0
  cpu: IRAM(0x20100000,0x150000) IRAM2(0x30100000,0x150000) IROM(0x00100000,0x200000) IROM2(0x10100000,0x200000) CPUTYPE("Cortex-M55") FPU3(DFPU) DSP TZ MVE(FP) CLOCK(12000000) ESEL ELITTLE
  output: libexecutorch_delegate_ethos_u (library)
  AfterMake: xcopy /Y .\Objects\libexecutorch_delegate_ethos_u.lib ..\
  c flags: Optim=3 OneElfS=1 v6Lang=5 v6LangP=9 wLevel=3
  c define: NDEBUG, ET_ENABLE_PROGRAM_VERIFICATION=0, ET_MIN_LOG=Info, C10_USING_CUSTOM_GENERATED_MACROS
  c include: ..\..\..\;..\..\..\..\Library\StdDriver\inc\npu;..\..\third-party\flatbuffers\include;..\..\runtime\core\portable_type\c10
  memory RVCT4: ROM 0x100000 size 0x200000
  memory RVCT5: ROM 0x10100000 size 0x200000
  memory RVCT9: RAM 0x20100000 size 0x150000
  memory RVCT10: RAM 0x30100000 size 0x150000
  group libexecutorch_delegate_ethos_u
    ../../backends/arm/runtime/: VelaBinStream.cpp
