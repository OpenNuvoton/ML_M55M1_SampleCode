# Keil uVision project libquantized_kernels.uvprojx, settings and files
target Release (6160000::V6.16::ARMCLANG)
  device: ARMCM55 ARM
  pack: ARM.CMSIS.5.8.0
  cpu: IRAM(0x30000000,0x00020000) IRAM2(0x20000000,0x00020000) IROM(0x10000000,0x00200000) IROM2(0x00000000,0x00200000) CPUTYPE("Cortex-M55") FPU3(DFPU) DSP TZ MVE(FP) CLOCK(12000000) ESEL ELITTLE
  output: libquantized_kernels (library)
  AfterMake: xcopy /Y .\Objects\libquantized_kernels.lib ..\
  c flags: Optim=3 OneElfS=1 v6Lang=5 v6LangP=8 wLevel=3
  c define: NDEBUG, ET_ENABLE_PROGRAM_VERIFICATION=0, ET_MIN_LOG=Info
  c include: ..\..\_prebuilt\schema\include;..\..\third-party\flatbuffers\include;..\..\..\..\ThirdParty;..\..\..\..\Library\StdDriver\inc\npu
  memory RVCT4: ROM 0x10000000 size 0x200000
  memory RVCT5: ROM 0x0 size 0x200000
  memory RVCT9: RAM 0x30000000 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  group libquantized_kernels
    ../../kernels/quantized/cpu/: op_add.cpp op_choose_qparams.cpp op_dequantize.cpp op_embedding.cpp op_embedding4b.cpp op_mixed_linear.cpp op_mixed_mm.cpp op_quantize.cpp
