# Keil uVision project libexecutorch.uvprojx, settings and files
target Release (6160000::V6.16::ARMCLANG)
  device: ARMCM55 ARM
  pack: ARM.CMSIS.5.8.0
  cpu: IRAM(0x30000000,0x00020000) IRAM2(0x20000000,0x00020000) IROM(0x10000000,0x00200000) IROM2(0x00000000,0x00200000) CPUTYPE("Cortex-M55") FPU3(DFPU) DSP TZ MVE(FP) CLOCK(12000000) ESEL ELITTLE
  output: libexecutorch (library)
  AfterMake: xcopy /Y .\Objects\libexecutorch.lib ..\
  c flags: Optim=3 OneElfS=1 v6Lang=5 v6LangP=8 wLevel=3
  c define: NDEBUG, ET_ENABLE_PROGRAM_VERIFICATION=0, ET_MIN_LOG=Info
  c include: ..\..\_prebuilt\schema\include;..\..\third-party\flatbuffers\include;..\..\..\..\ThirdParty;..\..\..\..\Library\StdDriver\inc\npu
  memory RVCT4: ROM 0x10000000 size 0x200000
  memory RVCT5: ROM 0x0 size 0x200000
  memory RVCT9: RAM 0x30000000 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  group libexecutorch
    ../../kernels/prim_ops/: et_copy_index.cpp et_view.cpp register_prim_ops.cpp
    ../../runtime/backend/: interface.cpp
    ../../runtime/core/: evalue.cpp
    ../../runtime/core/exec_aten/util/: tensor_util_portable.cpp
    ../../runtime/core/portable_type/: tensor_impl.cpp
    ../../runtime/executor/: method.cpp method_meta.cpp program.cpp tensor_parser_exec_aten.cpp tensor_parser_portable.cpp
    ../../runtime/kernel/: operator_registry.cpp
    ../../runtime/platform/: abort.cpp log.cpp profiler.cpp runtime.cpp
    ../../schema/: extended_header.cpp
