# Keil uVision project tflite_micro.uvprojx, settings and files
target Release (6220000::V6.22::ARMCLANG)
  device: ARMCM55 ARM
  pack: ARM.Cortex_DFP.1.1.0
  cpu: IRAM(0x30000000,0x00020000) IRAM2(0x20000000,0x00020000) IROM(0x10000000,0x00200000) IROM2(0x00000000,0x00200000) CPUTYPE("Cortex-M55") FPU3(DFPU) DSP TZ MVE(FP) CLOCK(12000000) ESEL ELITTLE
  output: tflu (library)
  AfterMake: xcopy /Y .\Objects\tflu.lib ..\
  c flags: Optim=3 OneElfS=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: CMSIS_NN, ETHOSU, FLATBUFFERS_LOCALE_INDEPENDENT=0, TF_LITE_STATIC_MEMORY, NDEBUG
  c include: ..\..\..\..\Library\CMSIS\Core\Include;..\..\..\..\Library\CMSIS\NN;..\..\..\..\Library\CMSIS\DSP\Include;..\..\_deps\tensorflow-gemlowp-src;..\..\_deps\tensorflow-flatbuffers-src\include;..\..\_deps\tensorflow-ruy-src;..\..\..\..\Library;..\..\..\..\Library\StdDriver\inc\npu;..\..\tensorflow;..\..\..\tflite_micro
  memory RVCT4: ROM 0x10000000 size 0x200000
  memory RVCT5: ROM 0x0 size 0x200000
  memory RVCT9: RAM 0x30000000 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  group micro-kernels-cmsis_nn
    ../../tensorflow/lite/micro/kernels/cmsis_nn/: add.cc conv.cc depthwise_conv.cc fully_connected.cc mul.cc pooling.cc softmax.cc svdf.cc transpose_conv.cc unidirectional_sequence_lstm.cc
  group micro-kernels-ethos_u
    ../../tensorflow/lite/micro/kernels/ethos_u/: ethosu.cc
  group micro-cortex_m_generic
    ../../tensorflow/lite/micro/cortex_m_generic/: debug_log.cc micro_time.cc
  group micro
    ../../tensorflow/lite/micro/: debug_log.cc fake_micro_context.cc flatbuffer_utils.cc memory_helpers.cc micro_allocation_info.cc micro_allocator.cc micro_context.cc micro_interpreter.cc micro_interpreter_context.cc micro_interpreter_graph.cc micro_log.cc micro_op_resolver.cc micro_profiler.cc micro_resource_variable.cc micro_utils.cc micro_utils_test.cc mock_micro_graph.cc recording_micro_allocator.cc system_setup.cc test_helper_custom_ops.cc test_helpers.cc
  group micro-memory_planner
    ../../tensorflow/lite/micro/memory_planner/: greedy_memory_planner.cc linear_memory_planner.cc non_persistent_buffer_planner_shim.cc
  group micro-kernels
    ../../tensorflow/lite/micro/kernels/: activations.cc activations_common.cc add.cc add_common.cc add_n.cc arg_min_max.cc assign_variable.cc batch_matmul.cc batch_to_space_nd.cc broadcast_args.cc broadcast_to.cc call_once.cc cast.cc ceil.cc circular_buffer.cc circular_buffer_common.cc circular_buffer_flexbuffers_generated_data.cc comparisons.cc concatenation.cc conv.cc conv_common.cc conv_test_common.cc cumsum.cc depth_to_space.cc depthwise_conv.cc depthwise_conv_common.cc dequantize.cc dequantize_common.cc detection_postprocess.cc detection_postprocess_flexbuffers_generated_data.cc div.cc elementwise.cc elu.cc embedding_lookup.cc exp.cc expand_dims.cc fill.cc floor.cc floor_div.cc floor_mod.cc fully_connected.cc fully_connected_common.cc gather.cc gather_nd.cc hard_swish.cc hard_swish_common.cc if.cc kernel_runner.cc kernel_util.cc l2_pool_2d.cc l2norm.cc leaky_relu.cc leaky_relu_common.cc log_softmax.cc logical.cc logical_common.cc logistic.cc logistic_common.cc lstm_eval.cc lstm_eval_common.cc maximum_minimum.cc micro_tensor_utils.cc mirror_pad.cc mul.cc mul_common.cc neg.cc pack.cc pad.cc pooling.cc pooling_common.cc prelu.cc prelu_common.cc quantize.cc quantize_common.cc read_variable.cc reduce.cc reduce_common.cc reshape.cc reshape_common.cc resize_bilinear.cc resize_nearest_neighbor.cc round.cc select.cc shape.cc slice.cc softmax.cc softmax_common.cc space_to_batch_nd.cc space_to_depth.cc split.cc split_v.cc squared_difference.cc squeeze.cc strided_slice.cc strided_slice_common.cc sub.cc sub_common.cc svdf.cc svdf_common.cc tanh.cc transpose.cc transpose_conv.cc unidirectional_sequence_lstm.cc unpack.cc var_handle.cc while.cc zeros_like.cc
  group core-api
    ../../tensorflow/lite/core/api/: error_reporter.cc flatbuffer_conversions.cc tensor_utils.cc
  group kernels
    ../../tensorflow/lite/kernels/: kernel_util.cc
  group kernels-internal
    ../../tensorflow/lite/kernels/internal/: common.cc quantization_util.cc portable_tensor_utils.cc runtime_shape.cc tensor_ctypes.cc tensor_utils.cc
  group kernels-internal-reference
    ../../tensorflow/lite/kernels/internal/reference/: portable_tensor_utils.cc
  group schema
    ../../tensorflow/lite/schema/: schema_utils.cc
  group core-c
    ../../tensorflow/lite/core/c/: common.cc
  group micro-tflite_bridge
    ../../tensorflow/lite/micro/tflite_bridge/: flatbuffer_conversions_bridge.cc micro_error_reporter.cc
  group micro-arena_allocator
    ../../tensorflow/lite/micro/arena_allocator/: non_persistent_arena_buffer_allocator.cc persistent_arena_buffer_allocator.cc recording_single_arena_buffer_allocator.cc single_arena_buffer_allocator.cc
